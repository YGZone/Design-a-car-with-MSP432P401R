# Keil uVision project MSP432P401R.uvprojx, settings and files
target MSP432P401R (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP432P401R
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c include: ..\Library\CMSIS\incldue;..\Library\ti\msp432p4xx\driverlib;..\Library\ti\msp432p4xx\inc;..\Bsp\common;..\Bsp\peripheral;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ../User/: main.c isr.c isr.h system.c system.h motor.c motor.h pid.c pid.h ps2gamepad.c ps2gamepad.h
    ../Bsp/peripheral/: servo.c servo.h encoder.c encoder.h
  group Bsp/Common
    ../Bsp/common/: All_Init.c All_Init.h headfile.h normal.c normal.h
  group Bsp/Peripheral
    ../Bsp/peripheral/: led.c led.h key.c key.h oled.c oled.h font.c font.h ANO_DT.c ANO_DT.h icm20602.c icm20602.h my_simiic.c my_simiic.h mpu6050.c mpu6050.h
  group Bsp/Doc
    ../Bsp/doc/: readme.txt pinout.txt
  group Driverlib
    ../Library/ti/msp432p4xx/driverlib/: adc14.c adc14.h aes256.c aes256.h comp_e.c comp_e.h cpu.c cpu.h crc32.c crc32.h cs.c cs.h debug.h dma.c dma.h driverlib.h eusci.h flash.c flash.h flash_a.c flash_a.h fpu.c fpu.h gpio.c gpio.h i2c.c i2c.h interrupt.c interrupt.h lcd_f.c lcd_f.h mpu.c mpu.h pcm.c pcm.h pmap.c pmap.h pss.c pss.h ref_a.c ref_a.h reset.c reset.h rom.h rom_map.h rtc_c.c rtc_c.h spi.c spi.h sysctl.c sysctl.h sysctl_a.c sysctl_a.h systick.c systick.h timer_a.c timer_a.h timer32.c timer32.h uart.c uart.h wdt_a.c wdt_a.h
  group Library
    ../Library/ti/msp432p4xx/start_up_system_files/: system_msp432p401r.c
    ../Library/ti/msp432p4xx/start_up_system_files/keil/: startup_msp432p401r_uvision.s
